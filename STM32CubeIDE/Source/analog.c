/*******************************************************************************
** Analog service
********************************************************************************
*
* Analog service
*
*
* v1.0
*
* (c) 10.2.2025
*
* use
*******************************************************************************/
#include "analog.h"


/******************************************************************************
** Defines
*******************************************************************************/

/******************************************************************************
** Constants
*******************************************************************************/

/******************************************************************************
** Variables
*******************************************************************************/
uint8_t  ain_count = AIN_COUNT;
uint16_t ain_rn;
uint8_t  sensor_type;
uint8_t  ain_fil_const;

ain_st   ain[AIN_COUNT];
aout_st  aout[AOUT_COUNT];

/******************************************************************************
** Functions
*******************************************************************************/

/******************************************************************************
** analog_init
*******************************************************************************
* Description    : Initialization analog part
* Input          : None
* Return         : None
*******************************************************************************/
void analog_init(void)
{
    uint8_t n;

    ain_count = AIN_COUNT;
    ain_rn = AIN_RN;
    sensor_type = TS_PT1000;
    ain_fil_const = 8;

    for (n = 0; n < AIN_COUNT; n++)
    {
        ain[n].t = 0;
        ain[n].offset = 0;
        ain[n].min = 0;
        ain[n].max = 99;
        ain[n].status = TS_INIT;
    }
    aout[0].mode = mAOUT_PWM;
    aout[0].value = 0;
    aout[0].status = 0;
}
/******************************************************************************
** analog_initSensorValues
*******************************************************************************
* Description    : Initialization sensor values
* Input          : None
* Return         : None
*******************************************************************************/
void analog_initSensorValues(void)
{
    uint8_t n;

    for (n = 0; n < AIN_COUNT; n++)
    {
        ain[n].t = 0;
        ain[n].status &= TS_USED;
    }
}

/******************************************************************************
** analog_setDefault
*******************************************************************************
* Description    : Setting to default values
* Input          : None
* Return         : None
*******************************************************************************/
void analog_setDefault(void)
{
    uint8_t i;

    ain_fil_const = 8;
    sensor_type = TS_PT1000;

    for (i = 0; i < AIN_COUNT; i++)
    {
        ain[i].offset = 0;
        ain[i].min = 0;
        ain[i].max = 99;
    }
}

/******************************************************************************
** analog_setDefaultCalib
*******************************************************************************
* Description    : Setting to default values
* Input          : None
* Return         : None
*******************************************************************************/
void analog_setDefaultCalib(void)
{
    uint8_t i;

    ain_rn = AIN_RN;
    for (i = 0; i < AIN_COUNT; i++)
    {
        ain[i].offset = 0;
    }
}

/******************************************************************************
** analog_service
*******************************************************************************
* Description    : ANALOG Service
* Input          : None
* Output         : None
* Return         : None
*******************************************************************************/
void analog_service(void)
{
}
